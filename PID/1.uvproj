# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Microchip
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: 1.omf +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: PID.c main.c ADC083X.c LCD1602.c
